Commit message: Create local CACTO-JAX

File: urdf/planar_manipulator_3dof.urdf (robot description, URDF)
Before this commit: robot planar_manipulator_3dof, 6 links, 5 joints
Links:
- link EE: geometry visual sphere radius=0.1
